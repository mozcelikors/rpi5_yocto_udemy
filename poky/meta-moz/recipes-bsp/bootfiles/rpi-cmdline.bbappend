CMDLINE_SERIAL = "console=ttyAMA0,115200"