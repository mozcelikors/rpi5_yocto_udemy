do_deploy:append() {
    echo "dtoverlay=uart0-pi5" >>$CONFIG
}
