do_install_ptest_base[noexec] = "1"
do_create_ptest_list[noexec] = "1"